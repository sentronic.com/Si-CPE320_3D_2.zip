Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 050423 CPE320.IFC
Time: 2023-04-06T08:52:53
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 19x1.5 O-ring-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19x1.5 O-ring-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19x1.5 O-ring-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Ecrou x-lock-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Embase x-lock-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mini-Din interface-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nut Hex M3-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nut Hex M3-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pressure interface-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pressure interface-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pressure-mini din plug-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pressure-mini din plug-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Pressure-mini din plug-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Screw CBT for TPE Ø2.5x6-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Screw CBT for TPE Ø2.5x6-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Screw CBT for TPE Ø2.5x6-3-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Screw CBT for TPE Ø2.5x6-4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Skeleton -4-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: TFT-480272-155-3 LCM ???1.step-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: cover-6-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: stainless steel Panel-3-solid1
In: Default Storey
PredefinedType: ELEMENT
